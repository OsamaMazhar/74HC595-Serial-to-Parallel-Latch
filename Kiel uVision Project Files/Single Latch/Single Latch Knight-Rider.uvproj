# Keil uVision project Single Latch Knight-Rider.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Single Latch Knight-Rider +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Single Latch Knight-Rider.c
